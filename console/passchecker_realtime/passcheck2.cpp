#include<iostream>
#include<cstring>
#include<stdio.h>
#include<conio.h>
#include<ctype.h>
#include"Defination.h"
using namespace std;
char star = '*';
int main(){
	cout<<"Password: \n";
	char str[300];
	char str_star[300];
	
///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////
	
	int i = 0;
	char GetCharNoEcho;
	
///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////
	
	while((GetCharNoEcho = getch())!='\r'){
		system("cls");
		if(GetCharNoEcho == '\b'){
			cout<<"\b";
			cout<<" ";
			str_star[i] = 0;
			str[i] = 0;	
			cout<<"\b";
			i--;		
		}
		else{
			str_star[i];
			str_star[i] = star;
			str[i] = GetCharNoEcho;
			i++;
		}
		
	//}
	
///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

	str[i] = 0;
	str_star[i] = 0;
///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

	ValidityCheck = InvalidityCheck(str)+Character8Check(str)+UpperLowerCaseCheck(str)+SymbolAndDigitCheck(str);

///////////////////////////////////////////////////////////////////////////////////////////////	
///////////////////////////////////////////////////////////////////////////////////////////////
	
	switch(ValidityCheck){
		case INVALID:
			//cout<<" Invalid \n";
			cout<<"Your password is: "<<str_star<<" and it is Invalid!";
		break;
		case WEAK:
			//cout<<" Weak \n";
			cout<<"Your password is: "<<str_star<<" and it is Weak";
		break;
		case ACCEPTABLE:
			//cout<<" Acceptable \n";
			cout<<"Your password is: "<<str_star<<" and it is Acceptable!";
		break;
		case GOOD:
			//cout<<" Good \n";
			cout<<"Your password is: "<<str_star<<" and it is Good!";
		break;
		case STRONG:
			//cout<<" Strong \n";
			cout<<"Your password is: "<<str_star<<" and it is Strong!";
		break;
	}
}
cout<<endl<<str;
	return 0;
}

///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

int SPACE_CHECKER;
const int one = 1;
const int zero = 0;

///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////MODULE ONE//////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

int InvalidityCheck(char *str){
	int i;
	for(i=0; str[i]; i++){
		if(str[i]==32){
			break;
		}
	}
	SPACE_CHECKER = ((strlen(str)<STRING_LENGTH) && (str[i]!=32) ? one:zero);	
	return SPACE_CHECKER;
}

///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////MODULE TWO//////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

int Character8Check(char *str){
	if(SPACE_CHECKER==one){
	return (strlen(str)>=8 ? one:zero);
	}
	else{
		return zero;
	}
}

///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////MODULE THREE////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

int UpperLowerCaseCheck(char *str){
	if(SPACE_CHECKER==one){
		int i=0;
		int up = 0;
		int low = 0;
		for(int i; str[i]; i++){
			if(isupper(str[i])){
				up = one;
			}
			else if(islower(str[i])){
				low = one;
			}
		}
		if(up==one && low==one){
			return one;
		}
		else{
			return zero;
		}
	}
	else{
		return zero;
	}
}

///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////MODULE FOUR/////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////

int SymbolAndDigitCheck(char *str){
	if(SPACE_CHECKER==one){
		int digsym, dig, sym = 0;
		for(int i=0; i<strlen(str); i++){
			char check = str[i];
			if(isdigit(check) || ispunct(check)){
				digsym++;
			}
			else{
				continue;
			}	
		}
		if(digsym>0){
			return one;
		}
		else{
			return zero;
		}
	}
	else{
		return zero;
	}
}

///////////////////////////////////////////////////////////////////////////////////////////////
///////////////////////////////////////////////////////////////////////////////////////////////
